# Keil uVision project test slave SPI.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: test slave SPI
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 c8051F020.h c8051F020_SFR16.h SPI_RingBuffer_Slave.h slave.c SPI_RingBuffer_Slave.c UART0_RingBuffer_lib.c UART0_RingBuffer_lib.h
