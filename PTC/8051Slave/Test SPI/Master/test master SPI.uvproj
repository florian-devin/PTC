# Keil uVision project test master SPI.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: test master SPI
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 c8051F020.h c8051F020_SFR16.h master.c SPI_RingBuffer_Master.c SPI_RingBuffer_Master.h PTC_strOperateurs.c PTC_strOperateurs.h PTC_geter_cmd.h PTC_SPI.h PTC_geter_cmd.c PTC_SPI.c
