# Keil uVision project Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Slave
  group Source Group 1
    ./: STARTUP.A51 config_globale.c main.c PTC_pointeurLumineux.c PTC_timer.c c8051F020.h c8051F020_SFR16.h config_globale.h PTC_pointeurLumineux.h PTC_timer.h PTC_PWM.h PTC_PWM.c PTC_servoMoteurVertical.c PTC_servoMoteurVertical.h PTC_strOperateurs.c PTC_strOperateurs.h PTC_geter_cmd.h PTC_geter_cmd.c PTC_accuseDeReception_SPI.c PTC_decodeCmd.c PTC_SPI.c SPI_RingBuffer_Slave.c UART0_RingBuffer_lib.c UART1_RingBuffer_lib.c PTC_accuseDeReception_SPI.h PTC_decodeCmd.h PTC_SPI.h SPI_RingBuffer_Slave.h UART0_RingBuffer_lib.h UART1_RingBuffer_lib.h PTC_convertion.h PTC_convertion.c
