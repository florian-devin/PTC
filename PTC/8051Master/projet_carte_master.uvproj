# Keil uVision project projet_carte_master.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projet_carte_master
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 c8051F020.h c8051F020_SFR16.h PTC_accuseDeReception.h PTC_convertion.h PTC_geter_cmd.h PTC_strOperateurs.h PTC_timer.h PTC_UART.h main.c PTC_accuseDeReception.c PTC_convertion.c PTC_geter_cmd.c PTC_strOperateurs.c PTC_timer.c PTC_UART.c config_globale.c config_globale.h PTC_deplacement.c PTC_detection.c PTC_math.c PTC_deplacement.h PTC_detection.h PTC_math.h UART0_RingBuffer_lib.c UART1_RingBuffer_lib.c UART0_RingBuffer_lib.h UART1_RingBuffer_lib.h PTC_servoMoteurHorizontal.h PTC_telemetre.h PTC_servoMoteurHorizontal.c PTC_telemetre.c PTC_decodeCmd.c PTC_decodeCmd.h SPI_RingBuffer_Master.c SPI_RingBuffer_Master.h
