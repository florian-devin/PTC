# Keil uVision project projetTR.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projetTR
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 config_globale.c PTC_timer.c TP4_Main_BSE.C c8051F020.h c8051F020_SFR16.h config_globale.h PTC_timer.h
